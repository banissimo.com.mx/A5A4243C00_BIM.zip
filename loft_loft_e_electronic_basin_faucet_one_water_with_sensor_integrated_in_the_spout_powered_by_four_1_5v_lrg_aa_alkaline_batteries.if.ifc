Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: loft_loft_e_electronic_basin_faucet_one_water_with_sensor_integrated_in_the_spout_powered_by_four_1_5v_lrg_aa_alkaline_batteries.ifc.ifc
Time: 2022-03-17T17:58:58
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal
ePset_BIMobjectScript - LOD: 300
ePset_BIMobject_BO - IfcClassification (BO_ifcclas): Sanitary Terminal
